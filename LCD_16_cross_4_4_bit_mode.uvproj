# Keil uVision project LCD_16_cross_4_4_bit_mode.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: LCD_16_cross_4_4_bit_mode
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 LCD_16_cross_4_4_bit_mode.c
